//Created by: J. Huang
//Create HDLC Frame from AX.25 frame then perform NRZI encoding
#include <iostream>
#include<cmath>
#include <vector>
#include<string>
#include <iomanip>

using namespace std;

static const unsigned short ccitt_table[256] = {
// from http://www.ietf.org/rfc/rfc1549.txt
   0x0000, 0x1189, 0x2312, 0x329b, 0x4624, 0x57ad, 0x6536, 0x74bf,
   0x8c48, 0x9dc1, 0xaf5a, 0xbed3, 0xca6c, 0xdbe5, 0xe97e, 0xf8f7,
   0x1081, 0x0108, 0x3393, 0x221a, 0x56a5, 0x472c, 0x75b7, 0x643e,
   0x9cc9, 0x8d40, 0xbfdb, 0xae52, 0xdaed, 0xcb64, 0xf9ff, 0xe876,
   0x2102, 0x308b, 0x0210, 0x1399, 0x6726, 0x76af, 0x4434, 0x55bd,
   0xad4a, 0xbcc3, 0x8e58, 0x9fd1, 0xeb6e, 0xfae7, 0xc87c, 0xd9f5,
   0x3183, 0x200a, 0x1291, 0x0318, 0x77a7, 0x662e, 0x54b5, 0x453c,
   0xbdcb, 0xac42, 0x9ed9, 0x8f50, 0xfbef, 0xea66, 0xd8fd, 0xc974,
   0x4204, 0x538d, 0x6116, 0x709f, 0x0420, 0x15a9, 0x2732, 0x36bb,
   0xce4c, 0xdfc5, 0xed5e, 0xfcd7, 0x8868, 0x99e1, 0xab7a, 0xbaf3,
   0x5285, 0x430c, 0x7197, 0x601e, 0x14a1, 0x0528, 0x37b3, 0x263a,
   0xdecd, 0xcf44, 0xfddf, 0xec56, 0x98e9, 0x8960, 0xbbfb, 0xaa72,
   0x6306, 0x728f, 0x4014, 0x519d, 0x2522, 0x34ab, 0x0630, 0x17b9,
   0xef4e, 0xfec7, 0xcc5c, 0xddd5, 0xa96a, 0xb8e3, 0x8a78, 0x9bf1,
   0x7387, 0x620e, 0x5095, 0x411c, 0x35a3, 0x242a, 0x16b1, 0x0738,
   0xffcf, 0xee46, 0xdcdd, 0xcd54, 0xb9eb, 0xa862, 0x9af9, 0x8b70,
   0x8408, 0x9581, 0xa71a, 0xb693, 0xc22c, 0xd3a5, 0xe13e, 0xf0b7,
   0x0840, 0x19c9, 0x2b52, 0x3adb, 0x4e64, 0x5fed, 0x6d76, 0x7cff,
   0x9489, 0x8500, 0xb79b, 0xa612, 0xd2ad, 0xc324, 0xf1bf, 0xe036,
   0x18c1, 0x0948, 0x3bd3, 0x2a5a, 0x5ee5, 0x4f6c, 0x7df7, 0x6c7e,
   0xa50a, 0xb483, 0x8618, 0x9791, 0xe32e, 0xf2a7, 0xc03c, 0xd1b5,
   0x2942, 0x38cb, 0x0a50, 0x1bd9, 0x6f66, 0x7eef, 0x4c74, 0x5dfd,
   0xb58b, 0xa402, 0x9699, 0x8710, 0xf3af, 0xe226, 0xd0bd, 0xc134,
   0x39c3, 0x284a, 0x1ad1, 0x0b58, 0x7fe7, 0x6e6e, 0x5cf5, 0x4d7c,
   0xc60c, 0xd785, 0xe51e, 0xf497, 0x8028, 0x91a1, 0xa33a, 0xb2b3,
   0x4a44, 0x5bcd, 0x6956, 0x78df, 0x0c60, 0x1de9, 0x2f72, 0x3efb,
   0xd68d, 0xc704, 0xf59f, 0xe416, 0x90a9, 0x8120, 0xb3bb, 0xa232,
   0x5ac5, 0x4b4c, 0x79d7, 0x685e, 0x1ce1, 0x0d68, 0x3ff3, 0x2e7a,
   0xe70e, 0xf687, 0xc41c, 0xd595, 0xa12a, 0xb0a3, 0x8238, 0x93b1,
   0x6b46, 0x7acf, 0x4854, 0x59dd, 0x2d62, 0x3ceb, 0x0e70, 0x1ff9,
   0xf78f, 0xe606, 0xd49d, 0xc514, 0xb1ab, 0xa022, 0x92b9, 0x8330,
   0x7bc7, 0x6a4e, 0x58d5, 0x495c, 0x3de3, 0x2c6a, 0x1ef1, 0x0f78
};



//Funtion written by John Langner, WB2OSZ  https://github.com/wb2osz/direwolf/blob/master/src/fcs_calc.c
unsigned short fcs_calc (unsigned char *data, int len) //calculate the FCS frame 
{
	unsigned short crc = 0xffff;
	int j;

	for (j=0; j<len; j++) {

  	  crc = ((crc) >> 8) ^ ccitt_table[((crc) ^ data[j]) & 0xff];
	}

	return ( crc ^ 0xffff );
}

string hexToBit(vector<uint8_t> &datalist){
    string bits;
    for(int i = 0; i<datalist.size();i++){
        for(int j = 0; j<8;j++){
            if((datalist[i] >> j) & 1){
              bits.push_back('1');
            }else{
              bits.push_back('0');
            }
        }
    }
    return bits;
}
string hexToBit2(vector<uint8_t> &datalist){ //does not invert the bits
    string bits;
    for(int i = 0; i<datalist.size();i++){
        for(int j = 7; j>=0;j--){
            if((datalist[i] >> j) & 1){
              bits.push_back('1');
            }else{
              bits.push_back('0');
            }
        }
    }
    return bits;
}
string btoi(string bytes){
    long int num = 0;
    for(int i = 0; i<bytes.size();i++){
        int bit;
        if(bytes[i] == '1') bit = 1;
        else bit = 0;
        if(bit) num = num+(pow(2,i));
    }
    string seq = to_string(num);
    return seq;
}

void appendFCS (string &bitString, uint16_t fcs){
    string bitsFCS;
    for(int i = 0; i<16;i++){
        if((fcs >> i) & 1){
            bitsFCS.push_back('1');
        }else{
            bitsFCS.push_back('0');
        }
    }
    bitString.append(bitsFCS);
    return;
}
void appendFlag(string &bitString){
    string flag = "01111110";
    for(int i = 0; i<flag.size();i++){
        bitString.insert(bitString.begin(), flag[i]);
        bitString.push_back(flag[i]);
    }
    return;
}
string bitStuffing(string &bitString){
    int count = 0;
    for(int i = 0 ;i<bitString.size();i++){
        if(bitString[i] == '1'){
            count++;
            if(count == 5){
                bitString.insert(i+1, "0");
                count = 0;
            }
        }
        else{
            count = 0;
        }
    }
    appendFlag(bitString);
    return bitString;
}
void sepByEight(string &bitString){ //add space every 8 bits for easier reading
    int count =0;
    for(int i = 0; i<bitString.size();i++){
        if(count==8){
            bitString.insert(i, " ");
            count = 0;
        }
        else count++;
    }
    return;
}
vector<bool> NRZI(string &HDLC){
    bool state = 1;
    vector<bool> NRZI;
    /*
    NRZI.push_back(0);
    NRZI.push_back(0);
    NRZI.push_back(0);
    NRZI.push_back(0);
    NRZI.push_back(0);
    NRZI.push_back(0);
    NRZI.push_back(0);
    NRZI.push_back(0);
    */
    /*
    for(int i = 1; i<HDLC.size();i++){
        if(HDLC[i] == HDLC[i-1]) NRZI.push_back(1);
        else  NRZI.push_back(0);
    }
    */
   
    for(int i = 0;i<HDLC.size();i++){
        if(HDLC[i] == '0'){
            state=!state;
        }
        NRZI.push_back(state);
    }
    NRZI.push_back(1);

    
    return NRZI;
}
int main(){
    //sample ax25 frame sourced from https://notblackmagic.com/bitsnpieces/ax.25/
    uint8_t ax25_result[100] = {0x82, 0xA0, 0xA4, 0xA6, 0x40, 0x40, 0xE0, 0x96, 0xA2, 0x68, 0x8C, 0xB2, 0xAA, 0x63, 0x03, 0xF0, 0x54, 0x68, 0x65, 0x20, 0x71, 0x75, 0x69, 0x63, 0x6B, 0x20, 0x62, 0x72, 0x6F, 0x77, 0x6E, 0x20, 0x66, 0x6F, 0x78, 0x20, 0x6A, 0x75, 0x6D, 0x70, 0x73, 0x20, 0x6F, 0x76, 0x65, 0x72, 0x20, 0x74, 0x68, 0x65, 0x20, 0x6C, 0x61, 0x7A, 0x79, 0x20, 0x64, 0x6F, 0x67};
    uint8_t hdlc_result[100] = {0x7E, 0x41, 0x05, 0x25, 0x65, 0x02, 0x02, 0x07, 0x69, 0x45, 0x16, 0x31, 0x4D, 0x55, 0xC6, 0xC0, 0x0F, 0x2A, 0x16, 0xA6, 0x04, 0x8E, 0xAE, 0x96, 0xC6, 0xD6, 0x04, 0x46, 0x4E, 0xF6, 0xEE, 0x76, 0x04, 0x66, 0xF6, 0x1E, 0x04, 0x56, 0xAE, 0xB6, 0x0E, 0xCE, 0x04, 0xF6, 0x6E, 0xA6, 0x4E, 0x04, 0x2E, 0x16, 0xA6, 0x04, 0x36, 0x86, 0x5E, 0x9E, 0x04, 0x26, 0xF6, 0xE6, 0xD5, 0x58, 0x7E};
    uint8_t hdlc_result2[100] = {0x7E, 0x41, 0x05, 0x25, 0x65, 0x02, 0x02, 0x07, 0x69, 0x45, 0x16, 0x31, 0x4D, 0x55, 0xC6, 0xC0, 0x0F, 0x2A, 0x16, 0xA6, 0x04, 0xB6, 0xA6, 0xCE, 0xCE, 0x86, 0xE6, 0xA6, 0x04, 0xEE, 0xF6, 0x4E, 0xD6, 0xCE, 0x74, 0x04, 0x2A, 0x16, 0x96, 0xCE, 0x04, 0x96, 0xCE, 0x04, 0xC6, 0xF6, 0xF6, 0x36, 0xF6, 0xA1, 0x7E};
    vector<uint8_t> AX25;
    vector<uint8_t> hdlc;
    vector<uint8_t> hdlc2;

    for(int i = 0; ax25_result[i]!=0;i++){
        AX25.push_back(ax25_result[i]);
    }
    for(int i = 0; hdlc_result[i]!=0;i++){
        hdlc.push_back(hdlc_result[i]);
    }
      for(int i = 0; hdlc_result2[i]!=0;i++){
        hdlc2.push_back(hdlc_result2[i]);
    }
    
    string hdlcbits = hexToBit2(hdlc);
    string hdlcbits2 = hexToBit2(hdlc2);
    uint16_t length = AX25.size();
    string bi = hexToBit(AX25);
    
    appendFCS(bi, fcs_calc(AX25.data(), length));
    
    string HDLC = bitStuffing(bi);
   
    //sepByEight(HDLC);  //separate by 8 bits for easier reading 
    sepByEight(hdlcbits);

    cout<<"mine HDLC: "<<HDLC<<endl;
    cout<<"web  HDLC: "<<hdlcbits<<endl;
    vector<bool> NRZI_encoded = NRZI(HDLC);
    cout<<"MINE NRZI: ";
    for(int i = 0; i<NRZI_encoded.size();i++){
        cout<<NRZI_encoded[i];
    }
    cout<<endl<<NRZI_encoded.size()<<endl;
    cout<<HDLC.size()<<endl;
    vector<bool> NRZI_encoded2 = NRZI(hdlcbits2);
    cout<<"NRZI2: ";
    for(int i = 0; i<NRZI_encoded2.size();i++){
        cout<<NRZI_encoded2[i];
    }
    return 0;
}